# Keil uVision project PWM.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\ADC;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\PWM;..\HARDWARE\SCAN;..\HARDWARE\Buzzer;..\HARDWARE\TIMER;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\IIC;..\HARDWARE\DMA;..\HARDWARE\move;..\HARDWARE\SOLGUI_V2-master;..\HARDWARE\SOLGUI_V2-master\Font;..\HARDWARE\SOLGUI_V2-master\OLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SCAN/: scan.c
    ../HARDWARE/Buzzer/: buzzer.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/move/: move.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group SOLGUI
    ../HARDWARE/SOLGUI_V2-master/: SOLGUI_Common.c SOLGUI_GBasic.c SOLGUI_Hardware.c SOLGUI_Menu.c SOLGUI_Picture.c SOLGUI_Printf.c SOLGUI_Widget.c
    ../HARDWARE/SOLGUI_V2-master/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
    ../HARDWARE/SOLGUI_V2-master/OLED/: OLED.c
