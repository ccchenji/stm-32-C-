# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\myFile\Key;..\myFile\oled\menu;..\myFile\oled\Queue;..\myFile\oled\Stack;..\myFile\IN;..\myFile\EXTI;..\myFile\PWM;..\myFile\TIMER;..\myFile\FDC2214;..\myFile\NiMing_Send;..\myFile\fliter;..\myFile\DealDate;..\myFile\oled\OLED(SPI)
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group OLED
    ../myFile/oled/menu/: menu.c
    ../myFile/oled/Queue/: Queue.c
    ../myFile/oled/Stack/: stack.c
    ../myFile/oled/OLED(SPI)/: oled.c
  group KEY
    ../myFile/Key/: key.c
  group EXTI
    ../myFile/EXTI/: EXTI.C
  group TIMER
    ../myFile/TIMER/: timer.c
  group FDC2214
    ../myFile/FDC2214/: FDC2214.c IIC.c
  group send
    ../myFile/NiMing_Send/: send.c
  group fliter
    ../myFile/fliter/: fliter.c
  group dealData
    ../myFile/DealDate/: dealDate.c
