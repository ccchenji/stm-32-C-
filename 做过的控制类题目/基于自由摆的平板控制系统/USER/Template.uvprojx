# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE;..\HARDWARE\OLED(SPI);..\HARDWARE\ADC_FIFTER;..\CORE;..\HARDWARE\REPORT;..\HARDWARE\KEY;..\HARDWARE\6050\Angle_balance;..\HARDWARE\6050\filter;..\HARDWARE\6050\MPU6050C8T6\eMPL;..\HARDWARE\6050\MPU6050C8T6;..\HARDWARE\DRIVER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/OLED(SPI)/: oled.c
    ../HARDWARE/ADC_FIFTER/: ADC_filter.c
    ../HARDWARE/REPORT/: report.c
    ../HARDWARE/KEY/: KEY.C
    ../HARDWARE/6050/Angle_balance/: Balance.c
    ../HARDWARE/6050/filter/: filter.c
    ../HARDWARE/6050/MPU6050C8T6/: mpuiic.c mpu6050.c
    ../HARDWARE/6050/MPU6050C8T6/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/DRIVER/: driver.c
